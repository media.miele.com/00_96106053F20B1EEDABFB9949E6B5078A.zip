Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-02-09T08:00:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Feb 09 08:00:56 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\0693a8f3-310b-4150-9187-dc6137d39662\94151e73-142f-48f4-bf69-d4f12b9e36ff\ifc * Database version: 5507 * Database creation date: Thu Feb 09 08:00:56 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Feb 09 08:00:56 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Feb 09 08:00:56 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11954020_AUS_KFN4776ED_EDTCS:38477650_AUS_11954020_KFN4776ED_EDTCS, (2)
In: Default
Type - Material: z_Miele_Design_Glass Black
Type - Pset_BuildingElementProxyCommon - Reference: 38477650_AUS_11954020_KFN4776ED_EDTCS
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_QuantityTakeOff - Reference: 38477650_AUS_11954020_KFN4776ED_EDTCS
Type - Pset_ProvisionForVoid - Width: 747 mm; Height: 1859 mm; Depth: 630 mm
Material: z_Miele_Design_Glass Black, z_Miele_Design_OBSW, z_Miele_Design_CLST, z_Miele_Connection_Electric, z_Miele_Connection_Connection_Modul, z_Miele_Design_Steel_Chrom
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProductRequirements - Category: Specialty Equipment
